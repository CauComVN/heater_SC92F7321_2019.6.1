# Keil uVision project heater.uvproj, settings and files
target Target (MCS-51)
  device: SC92F7321 SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0-0xFF) CLOCK(24000000)
  output: heater +hex
  c flags: SizeSpeed=1
  c include: .\H
  group Doc
    ./doc/: NTC-100K-3950-阻值表及AD值计算.xls NTC热敏电阻(-30-150)-3950-50K.pdf NTC热敏电阻(-30-150)-3950-50K.txt readme.txt 单片机ADC温度采集原理.doc
  group H
    ./H/: Function_Init.H SC92F732X_C.H ADC.h
  group c
    ./c/: ADC_Init.c IO_Init.c main.c Timer_Init.c Uart_Init.c Scr_Driver.c Water_Check.c Leakage_Check.c interrupt.c BTM.c
    ./: STARTUP.A51
